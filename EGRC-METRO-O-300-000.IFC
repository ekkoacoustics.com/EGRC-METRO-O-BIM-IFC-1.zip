Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Metro\EGRC-METRO-O-300-000.IFC
Time: 2025-01-03T10:53:33+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 85.7520000000001517; Volume Measure: 0.0857520000000002; Area Measure: 15.0573373505963293

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 85.7520000000001517; Volume Measure: 0.0857520000000002; Area Measure: 15.0573373505963293

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 85.7520000000001517; Volume Measure: 0.0857520000000002; Area Measure: 15.0573373505963293

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-METRO-O-300-000 | PSet_Mass_Property - Mass Measure: 85.7520000000001517; Volume Measure: 0.0857520000000002; Area Measure: 15.0573373505963293
EGRC-METRO-O-300-000
