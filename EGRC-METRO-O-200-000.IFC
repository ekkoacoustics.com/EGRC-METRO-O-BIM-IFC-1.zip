Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Metro\EGRC-METRO-O-200-000.IFC
Time: 2025-01-03T10:54:33+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 57.1679999999999424; Volume Measure: 0.0571679999999999; Area Measure: 10.2296489003975584

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 57.1679999999999424; Volume Measure: 0.0571679999999999; Area Measure: 10.2296489003975584

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 57.1679999999999424; Volume Measure: 0.0571679999999999; Area Measure: 10.2296489003975584

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-METRO-O-200-000 | PSet_Mass_Property - Mass Measure: 57.1679999999999424; Volume Measure: 0.0571679999999999; Area Measure: 10.2296489003975584
EGRC-METRO-O-200-000
