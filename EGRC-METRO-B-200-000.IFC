Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Metro Box\EGRC-METRO-B-200-000.IFC
Time: 2025-01-03T14:05:33+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 132.1309439999999711; Volume Measure: 0.1321309440000001; Area Measure: 23.8428771177482659

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 132.1309439999999711; Volume Measure: 0.1321309440000001; Area Measure: 23.8428771177482659

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 132.1309439999999711; Volume Measure: 0.1321309440000001; Area Measure: 23.8428771177482659

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-METRO-B-200-000 | PSet_Mass_Property - Mass Measure: 132.1309439999999711; Volume Measure: 0.1321309440000001; Area Measure: 23.8428771177482659
EGRC-METRO-B-200-000
