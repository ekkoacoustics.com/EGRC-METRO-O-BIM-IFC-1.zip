Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Metro Box\EGRC-METRO-B-300-000.IFC
Time: 2025-01-03T14:04:34+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 160.7149440000000595; Volume Measure: 0.1607149440000002; Area Measure: 28.6705655679470262

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 160.7149440000000595; Volume Measure: 0.1607149440000002; Area Measure: 28.6705655679470262

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 160.7149440000000595; Volume Measure: 0.1607149440000002; Area Measure: 28.6705655679470262

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-METRO-B-300-000 | PSet_Mass_Property - Mass Measure: 160.7149440000000595; Volume Measure: 0.1607149440000002; Area Measure: 28.6705655679470262
EGRC-METRO-B-300-000
