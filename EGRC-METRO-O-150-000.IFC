Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Metro\EGRC-METRO-O-150-000.IFC
Time: 2025-01-03T10:55:24+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 42.8759999999998414; Volume Measure: 0.0428759999999998; Area Measure: 7.8228606752981751

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 42.8759999999998414; Volume Measure: 0.0428759999999998; Area Measure: 7.8228606752981751

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 42.8759999999998414; Volume Measure: 0.0428759999999998; Area Measure: 7.8228606752981751

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-METRO-O-150-000 | PSet_Mass_Property - Mass Measure: 42.8759999999998414; Volume Measure: 0.0428759999999998; Area Measure: 7.8228606752981751
EGRC-METRO-O-150-000
