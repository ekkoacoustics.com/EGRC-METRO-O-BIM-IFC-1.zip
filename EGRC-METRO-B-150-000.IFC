Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Metro Box\EGRC-METRO-B-150-000.IFC
Time: 2025-01-03T14:06:26+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 117.8389440000001827; Volume Measure: 0.1178389440000001; Area Measure: 21.4360888926488755

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 117.8389440000001827; Volume Measure: 0.1178389440000001; Area Measure: 21.4360888926488755

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 117.8389440000001827; Volume Measure: 0.1178389440000001; Area Measure: 21.4360888926488755

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-METRO-B-150-000 | PSet_Mass_Property - Mass Measure: 117.8389440000001827; Volume Measure: 0.1178389440000001; Area Measure: 21.4360888926488755
EGRC-METRO-B-150-000
