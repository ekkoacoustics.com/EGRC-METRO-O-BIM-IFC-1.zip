Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Metro\EGRC-METRO-O-300-000 FULL ASSEMBLY.IFC
Time: 2025-01-03T10:46:46+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 86.1276756474980516; Volume Measure: 0.0861276756474983; Area Measure: 15.4650817859256478

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 86.1276756474980516; Volume Measure: 0.0861276756474983; Area Measure: 15.4650817859256478

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 86.1276756474980516; Volume Measure: 0.0861276756474983; Area Measure: 15.4650817859256478

# IfcBuildingElementProxy (142)
In: default BuildingStorey
Name
EGRC-METRO-O-300-000 FULL ASSEMBLY | PSet_Mass_Property - Mass Measure: 86.1276756474980516; Volume Measure: 0.0861276756474983; Area Measure: 15.4650817859256478
H Section Hanging Extrusion + F000264 P50 Suspension Fitting
20 x H Section Hanging Extrusion - 100mm
20 x F000264 P50 SUSPENSION FITTING.SLDPRT
20 x F000264 P50 Clutch Fitting
20 x F000264 P50 Top Threaded Insert
20 x F000264 P50 Tensile Steel Wire 2m
20 x F000264 P50 M5 Threaded Bolt
EGRC-METRO-O-300-000
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-1
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-2
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-3
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-4
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-5
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-6
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-7
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-8
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-9
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-10
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-11
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-12
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-13
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-14
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-15
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-16
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-17
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-18
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-19
